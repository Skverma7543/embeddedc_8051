# Keil uVision project home_automation.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: main_uc +hex
  c flags: Optimize=8 SizeSpeed=1
  group driver
    ../: delay_driver.c cgram_driver.c Ex_interrupt_driver.c i2c_driver.c io_driver.c keypad_cal_driver.c keypad_phone_driver.c lm016l_lcd4_driver.c timer_interrupt_driver.c uart_driver.c
    ./: home_automation_drivers.c
  group application
    ./: home_automation_main.c
  group uc1
    ./: uc1main.c uc1driver.c
  group uc2
    ./: uc2driver.c uc2main.c
  group uc3
    ./: uc3driver.c uc3main.c
