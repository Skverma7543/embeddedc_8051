# Keil uVision project at89c51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Applications
    ./: io_main.c
  group Drivers
    ./: io_driver.c delay_driver.c
